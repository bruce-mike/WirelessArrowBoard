# Keil uVision project Repeater.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2366 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Repeater +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L
  c flags: Optim=3
  c misc: -DRADIO_V2 -DPCBA_REV_K -DACCEL_BMA255
  c include: C:\Keil\ARM\INC\Phillips;../SharedLibrary
  memory RVCT4: ROM 0x0 size 0x3d000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup
    ./: LPC2300.s
  group Code
    ./: main.c ADC.c adc.h mischardware.c mischardware.h retarget.c flash_nvol.h ArrowBoardDefs.h commands.c
    ../SharedLibrary/: sharedinterface.h SharedLibrary.lib
