# Keil uVision project Handheld.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2387 NXP
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Handheld +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L
  c flags: Optim=1
  c misc: -DRADIO_V2 -DDEBUGOUT=3
  c include: C:\Keil\ARM\INC\Philips;../SharedLibrary
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group STARTUP
    ./: LPC2300.s
  group CODE
    ./: retarget.c menufunctions.c main.c commboard.c pwm.c status.c spiFlashUI.c gen_UI.c LCD.c UI.c uidriver.c commands.c runlength.c ADC.c adc.h
    ../SharedLibrary/: SharedLibrary.lib queue.h
