# Keil uVision project SharedLibrary.uvproj, settings and files
target SharedLibrary (ARM-ADS)
  device: LPC2366 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SharedLibrary (library)
  c flags: Optim=2
  c misc: -DRADIO_V2 -DPCBA_REV_K -DDEBUGOUT=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Code
    ./: i2c.c queue.c timer.c i2c.h queue.h sharedinterface.h timer.h flash_nvol.c irq.c hdlc.c wireless.c serial.c PLL.c shareddefs.h ssp.c spiflash.c storedconfig.c storedconfig.h watchdog.c watchdog.h
